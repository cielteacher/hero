# Keil uVision project sinserely.uvprojx, settings and files
target sinserely (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: sinserely +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../User/Algorithm;../User/BSP;../User/Device/vofa+;../User/Device/remote_control;../User/Device/music;../User/Device/motor;../User/Device/BMI088;../User/Gimbal;../User/Shoot;../User/Task;../User/robot;../User/Device/can_comm;../User/Cmd;../User/Device/MiniPC
  asm include: ../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: sinserely\sinserely.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c cordic.c dma.c fdcan.c spi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cordic.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Library/DSP Library/DSP Library
    $TC_ROOT$/../../Desktop/sincerely/Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group Algorithm
    ../User/Algorithm/: Kalman_Filter.c Kalman_Filter.h pid.c pid.h Quaternion.c Quaternion.h RMLibHead.h RMQueue.c RMQueue.h slope.c slope.h CRC.c CRC.h LPF.c LPF.h
  group Bsp
    ../User/BSP/: bsp_dwt.c bsp_dwt.h bsp_fdcan.c bsp_fdcan.h bsp_gpio.c bsp_gpio.h bsp_spi.c bsp_spi.h bsp_usart.c bsp_usart.h bsp_pwm.c bsp_pwm.h
  group Device
    ../User/Device/vofa+/: vofa.c vofa.h
    ../User/Device/remote_control/: remote.c remote.h
    ../User/Device/music/: music.c music.h
    ../User/Device/motor/: DJImotor.c DJImotor.h DMmotor.c DMmotor.h motor.c motor.h
    ../User/Device/can_comm/: can_comm.c can_comm.h
    ../User/Device/BMI088/: BMI088driver.c BMI088driver.h
    ../User/Device/MiniPC/: MiniPC.c MiniPC.h
  group Gimbal
    ../User/Gimbal/: Gimbal.c Gimbal.h
  group Shoot
    ../User/Shoot/: Shoot.c Shoot.h
  group robot
    ../User/robot/: robot.h
  group Cmd
    ../User/Cmd/: Gimbal_Cmd.h Gimbal_Cmd.c
  group Task
    ../User/Task/: Task_Gimbal.c Task_Gimbal.h TASK_Init.c TASK_Init.h Task_Data.c Task_Data.h
software components: CMSIS:CORE 5.4.0
